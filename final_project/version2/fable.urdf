Commit message: Classical method now works

File: final_project/version2/fable.urdf (robot description, URDF)
Before this commit: robot robot, 4 links, 3 joints
Joints:
- joint base_link_to_cylinder2: axis 0 0 1 -> 0 0 -1
